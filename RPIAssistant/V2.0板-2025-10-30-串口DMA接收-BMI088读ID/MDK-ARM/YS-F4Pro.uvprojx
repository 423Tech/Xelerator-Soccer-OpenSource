# Keil uVision project YS-F4Pro.uvprojx, settings and files
target YS-F4Pro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YS-F4Pro
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Inc\bsp;..\Src\bsp\board_check;..\Src\bsp\adc;..\Src\bsp\motor;..\Src\bsp\key;..\Src\bsp\led;..\Src\bsp\usart;..\Src\bsp\stmflash;..\Src\bsp\system;..\Src\bsp\Encoder;..\Src\bsp\PID;..\Src\bsp\CAR;..\Src\bsp\TIMER;..\Src\bsp\BMI088;..\Src\bsp\spi;..\Src\bsp\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_assert.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma2d.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group bsp
    ../Src/bsp/system/: system.c
    ../Src/bsp/usart/: usart.c
    ../Src/bsp/stmflash/: stm_flash.c
    ../Src/bsp/board_check/: myiic.c
    ../Src/bsp/adc/: adc.c
    ../Src/bsp/TIMER/: timer.c
    ../Src/bsp/motor/: motor.c
    ../Src/bsp/led/: led.c
    ../Src/bsp/key/: key.c
    ../Src/bsp/Encoder/: Encoder.c
    ../Src/bsp/PID/: pid.c
    ../Src/bsp/CAR/: car.c car_RTU.c
    ../Src/bsp/spi/: spi.c
    ../Src/bsp/IMU/: IMU.c
  group BMI088
    ../Src/bsp/BMI088/: BMI088driver.c BMI088Middleware.c
  group Readme
    ../Readme/: 01.开发环境说明.txt
